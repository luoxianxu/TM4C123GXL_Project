# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: ..\User;..\inc;..\driverlib;..\Libraries;..\Hardware\Key;..\Hardware\RGB_LED;..\Hardware\USART;..\Hardware\Timer;..\Hardware\Pwm;..\Hardware\I2C;..\Hardware\Encorder;..\Hardware\SPI;..\Hardware\DMA;..\Hardware\Adc;..\Hardware\MPU6050;..\Hardware\oled;..\Hardware\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../Libraries/CMSIS/: startup_rvmdk.S
  group User
    ../User/: main.c
  group Hardware
    ../Hardware/Key/: key.c
    ../Hardware/RGB_LED/: rgb.c
    ../Hardware/USART/: usart.c
    ../Hardware/Timer/: myTimer.c
    ../Hardware/Pwm/: myPwm.c
    ../Hardware/I2C/: myI2C.c
    ../Hardware/SPI/: mySPI.c
    ../Hardware/Encorder/: myEncorder.c
    ../Hardware/DMA/: myDMA.c
    ../Hardware/Adc/: myAdc.c
    ../Hardware/MPU6050/: mpu6050.c mpu6050_firRefi.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/oled/: oled.c
    ../Hardware/EEPROM/: myEEPROM.c
  group Libraries
    ../Libraries/src/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ../Libraries/utils/: uartstdio.c
